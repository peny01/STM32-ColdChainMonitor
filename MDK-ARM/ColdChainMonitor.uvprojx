# Keil uVision project ColdChainMonitor.uvprojx, settings and files
target LED (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F051K8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver\Inc;../Drivers/STM32F0xx_HAL_Driver\Inc\Legacy;../Drivers/CMSIS\Device\ST\STM32F0xx\Include;../Drivers/CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f051x8.s
  group Application/User
    ../Src/: main.c dht22.c mpu6050.c gps.c esp8266.c mqtt.c alarm.c lcd.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c
software components: CMSIS:CORE 4.3.0
